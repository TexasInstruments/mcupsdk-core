<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/usb_dfu_am261x-lp_r5fss0-0_freertos.ewp</path>
    </project>
    <batchBuild/>
</workspace>
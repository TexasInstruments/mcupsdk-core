<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/ospi_flash_file_io_am261x-lp_r5fss0-0_nortos.ewp</path>
    </project>
    <batchBuild/>
</workspace>
# IAR project ospi_flash_file_io_am261x-lp_r5fss0-0_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ospi_flash_file_io_am261x-lp_r5fss0-0_freertos.ipcf sysconfig_generated_files.ipcf

<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>4</fileVersion>
    <configuration>
        <name>debug</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>34</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CEndian</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CProcessor</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>MemOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MemFile</name>
                    <state></state>
                </option>
                <option>
                    <name>RunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>RunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>CExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>CFpuProcessor</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDDFArgumentProducer</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCProductVersion</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDynDriverList</name>
                    <state>XDS100_ID</state>
                </option>
                <option>
                    <name>OCLastSavedByProductVersion</name>
                    <state></state>
                </option>
                <option>
                    <name>UseFlashLoader</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CLowLevel</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCBE8Slave</name>
                    <state>1</state>
                </option>
                <option>
                    <name>MacFile2</name>
                    <state></state>
                </option>
                <option>
                    <name>CDevice</name>
                    <state>1</state>
                </option>
                <option>
                    <name>FlashLoadersV3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>OverrideDefFlashBoard</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDeviceConfigMacroFile</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDebuggerExtraOption</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCAllMTBOptions</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreNrOfCores</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreWorkspace</name>
                    <state></state>
                </option>
                <option>
                    <name>OCMulticoreSlaveProject</name>
                    <state></state>
                </option>
                <option>
                    <name>OCMulticoreSlaveConfiguration</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDownloadExtraImage</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCAttachSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MassEraseBeforeFlashing</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreNrOfCoresSlave</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreAMPConfigType</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCMulticoreSessionFile</name>
                    <state></state>
                </option>
                <option>
                    <name>OCTpiuBaseOption</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCOverrideSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCOverrideSlavePath</name>
                    <state></state>
                </option>
                <option>
                    <name>C_32_64Device</name>
                    <state>1</state>
                </option>
                <option>
                    <name>AuthEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>AuthSdmSelection</name>
                    <state>1</state>
                </option>
                <option>
                    <name>AuthSdmManifest</name>
                    <state></state>
                </option>
                <option>
                    <name>AuthSdmExplicitLib</name>
                    <state></state>
                </option>
                <option>
                    <name>AuthEnforce</name>
                    <state>0</state>
                </option>
                <option>
                    <name>VectorTableOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>VectorTableExpr</name>
                    <state>__vector</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>XDS100_ID</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>9</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OCDriverInfo</name>
                    <state>1</state>
                </option>
                <option>
                    <name>TIPackageOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TIPackage</name>
                    <state>C:\ti\iar\ccs_base</state>
                </option>
                <option>
                    <name>BoardFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\TexasInstruments\xds\AM261x_XDS110_JTAG.dat</state>
                </option>
                <option>
                    <name>DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>CCXds100BreakpointRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100DoUpdateBreakpoints</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100UpdateBreakpoints</name>
                    <state>_call_main</state>
                </option>
                <option>
                    <name>CCXds100CatchReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchUndef</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchSWI</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchPrefetch</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchIRQ</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchFIQ</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchCORERESET</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchMMERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchNOCPERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchCHRERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchSTATERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchBUSERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchINTERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchSFERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchHARDERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchDummy</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CpuClockEdit</name>
                    <state></state>
                </option>
                <option>
                    <name>CCXds100SwoClockAuto</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100SwoClockEdit</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>CCXds100HWResetDelay</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100ResetList</name>
                    <version>1</version>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100UsbSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>CCXds100UsbSerialNoSelect</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100JtagSpeedList</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100InterfaceRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100InterfaceCmdLine</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100ProbeList</name>
                    <version>0</version>
                    <state>3</state>
                </option>
                <option>
                    <name>CCXds100SWOPortRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100SWOPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CCXDSTargetVccEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXDSTargetVoltage</name>
                    <state>3.3</state>
                </option>
                <option>
                    <name>OCXDSDigitalStatesConfigFile</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCSelectedCoreName</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <configuration>
        <name>release</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>0</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>34</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CEndian</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CProcessor</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>MemOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MemFile</name>
                    <state></state>
                </option>
                <option>
                    <name>RunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>RunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>CExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>CFpuProcessor</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDDFArgumentProducer</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCProductVersion</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDynDriverList</name>
                    <state>XDS100_ID</state>
                </option>
                <option>
                    <name>OCLastSavedByProductVersion</name>
                    <state></state>
                </option>
                <option>
                    <name>UseFlashLoader</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CLowLevel</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCBE8Slave</name>
                    <state>1</state>
                </option>
                <option>
                    <name>MacFile2</name>
                    <state></state>
                </option>
                <option>
                    <name>CDevice</name>
                    <state>1</state>
                </option>
                <option>
                    <name>FlashLoadersV3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>OverrideDefFlashBoard</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDeviceConfigMacroFile</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDebuggerExtraOption</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCAllMTBOptions</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreNrOfCores</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreWorkspace</name>
                    <state></state>
                </option>
                <option>
                    <name>OCMulticoreSlaveProject</name>
                    <state></state>
                </option>
                <option>
                    <name>OCMulticoreSlaveConfiguration</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDownloadExtraImage</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCAttachSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MassEraseBeforeFlashing</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreNrOfCoresSlave</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreAMPConfigType</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCMulticoreSessionFile</name>
                    <state></state>
                </option>
                <option>
                    <name>OCTpiuBaseOption</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCOverrideSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCOverrideSlavePath</name>
                    <state></state>
                </option>
                <option>
                    <name>C_32_64Device</name>
                    <state>1</state>
                </option>
                <option>
                    <name>AuthEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>AuthSdmSelection</name>
                    <state>1</state>
                </option>
                <option>
                    <name>AuthSdmManifest</name>
                    <state></state>
                </option>
                <option>
                    <name>AuthSdmExplicitLib</name>
                    <state></state>
                </option>
                <option>
                    <name>AuthEnforce</name>
                    <state>0</state>
                </option>
                <option>
                    <name>VectorTableOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>VectorTableExpr</name>
                    <state>__vector</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>XDS100_ID</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>9</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OCDriverInfo</name>
                    <state>1</state>
                </option>
                <option>
                    <name>TIPackageOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TIPackage</name>
                    <state>C:\ti\iar\ccs_base</state>
                </option>
                <option>
                    <name>BoardFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>CCXds100BreakpointRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100DoUpdateBreakpoints</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100UpdateBreakpoints</name>
                    <state>_call_main</state>
                </option>
                <option>
                    <name>CCXds100CatchReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchUndef</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchSWI</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchPrefetch</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchIRQ</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchFIQ</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchCORERESET</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchMMERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchNOCPERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchCHRERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchSTATERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchBUSERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchINTERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchSFERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchHARDERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CatchDummy</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100CpuClockEdit</name>
                    <state></state>
                </option>
                <option>
                    <name>CCXds100SwoClockAuto</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100SwoClockEdit</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>CCXds100HWResetDelay</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100ResetList</name>
                    <version>1</version>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100UsbSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>CCXds100UsbSerialNoSelect</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100JtagSpeedList</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100InterfaceRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100InterfaceCmdLine</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100ProbeList</name>
                    <version>0</version>
                    <state>3</state>
                </option>
                <option>
                    <name>CCXds100SWOPortRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXds100SWOPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CCXDSTargetVccEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCXDSTargetVoltage</name>
                    <state>3.3</state>
                </option>
                <option>
                    <name>OCXDSDigitalStatesConfigFile</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCSelectedCoreName</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
</project>
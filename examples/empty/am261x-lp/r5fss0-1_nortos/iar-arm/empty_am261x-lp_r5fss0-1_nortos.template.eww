<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/empty_am261x-lp_r5fss0-1_nortos.ewp</path>
    </project>
    <batchBuild/>
</workspace>